require conf/distro/include/security_flags.inc
